# Keil uVision project yyh.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: yyh +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: yyh.c LCD1602.c
